## boards/shields/rgbled_adapter/Kconfig.defconfig
```kconfig
if SHIELD_RGBLED_ADAPTER

config ZMK_KEYBOARD_NAME
    default "rgbled_adapter"

endif
```
